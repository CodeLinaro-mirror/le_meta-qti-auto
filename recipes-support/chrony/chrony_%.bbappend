FILESEXTRAPATHS_prepend := "${THISDIR}/chrony:"
