FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI +="file://${BASEMACHINE}/find_recovery_partitions.sh"
