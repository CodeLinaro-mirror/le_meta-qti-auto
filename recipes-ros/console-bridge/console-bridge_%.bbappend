FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append += "file://0001-Install-console_bridge-libs-to-usr-lib64.patch"
