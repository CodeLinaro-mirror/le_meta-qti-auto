CXXFLAGS_append = " -D__ANDROID__"
