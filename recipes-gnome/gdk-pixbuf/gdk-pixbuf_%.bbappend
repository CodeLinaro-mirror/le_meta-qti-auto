DEPENDS += "tiff"
GDK_PIXBUF_LOADERS = "tiff"
