FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://no-shell-history.cfg"
