SRC_URI_remove_arm = " file://arm/local-arm-futex.diff "
SRC_URI_append_arm = " https://source.codeaurora.org/quic/le/AGL/meta-agl/plain/meta-agl-profile-core/recipes-core/glibc/glibc/arm/local-arm-futex.diff?h=automotivelinux/flounder;downloadfilename=local-arm-futex.diff;md5sum=0e9e19f02bc8b5cab868388fbeabc76a;sha256sum=18b147b148062735c3a59b12fda208097fa9e7609f69eb975c7e3e4c42aa2a5d "
