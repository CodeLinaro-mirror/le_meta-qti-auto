FILESEXTRAPATHS:prepend := "${THISDIR}/coreutils-6.9:"

SRC_URI += "file://0001-sort.c-Reorder-includes-for-glibc-2.34-portability.patch"

