RDEPENDS_packagegroup-android-utils-base_remove_qti-distro-teleap = "\
    binder \
    "
