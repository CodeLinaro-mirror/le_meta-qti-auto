RDEPENDS_packagegroup-qti-virtualization_append = "\
    svmclkproxy \
"
