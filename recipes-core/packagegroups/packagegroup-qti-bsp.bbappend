RDEPENDS:packagegroup-support-utils:append = " \
    chronyc \
"
