require dbus-cynara.inc

FILESEXTRAPATHS_prepend := "${COREBASE}/meta-agl/meta-agl/recipes-core/dbus/dbus:"

