AGL_APPS_remove = " \
    high-level-viwi-service \
    poiapp \
    "

RDEPENDS_${PN}_remove = " \
    ${MOST_HVAC} \
    "
