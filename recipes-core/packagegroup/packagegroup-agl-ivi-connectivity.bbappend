RDEPENDS_${PN}_remove = "\
    rygel \
    rygel-plugin-media-export \
    rygel-plugin-lms \
    "
