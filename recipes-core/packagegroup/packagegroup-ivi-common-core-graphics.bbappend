RDEPENDS_${PN}_remove = "\
    weston-init weston-ini-conf \
    "
