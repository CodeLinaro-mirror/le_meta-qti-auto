RPROVIDES_libasound += "alsa-lib"
