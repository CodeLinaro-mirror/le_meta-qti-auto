EXTRA_OECONF_append = " --disable-libsync"

COMPOSITION = "901D"
