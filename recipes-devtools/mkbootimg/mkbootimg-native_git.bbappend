EXTRA_OEMAKE = "INCLUDES='-Imincrypt' LIBS='-lmincrypt'" 
