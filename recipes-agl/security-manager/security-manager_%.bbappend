# Remove security-manager policy
# This will be updated by cynara policy service
pkg_postinst_${PN}-policy () {
    exit 0
}
