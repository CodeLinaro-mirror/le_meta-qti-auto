RDEPENDS_${PN}-tests_remove = "dbus-x11"
RDEPENDS_${PN}-tests += "dbus"
