RDEPENDS_${PN}_remove = "\
    opencv \
    "
