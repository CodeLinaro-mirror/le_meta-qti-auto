CPPFLAGS:append:arm = " -DUATOMIC_NO_LINK_ERROR"
