DEPENDS_remove = "virtual/libgl"
RDEPENDS_${PN}_remove = "flite openjtalk"
