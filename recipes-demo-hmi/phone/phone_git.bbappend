SRC_URI_append = "\
    https://source.codeaurora.org/quic/le/AGL/apps/phone/patch/telephony-binding/gdbus/ofono_voicecallmanager.c?id=839685b2c5c3089c7b41e3e0d556c0fe963a9605;downloadfilename=0001-Fix-build-error-in-gcc-7.2.patch;md5sum=b8e62c9f97d465f65042bdbf48e4bcba;sha256sum=ad500acfd351a68419bd2a2aa95c62c089a92d5e8c582214ec3204fe214b0b8d \
    "
