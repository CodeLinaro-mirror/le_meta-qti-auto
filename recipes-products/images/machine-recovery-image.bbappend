# Auto OPEN SOURCE PACKAGES
include ${BASEMACHINE}/${MACHINE}-recovery-image.inc
